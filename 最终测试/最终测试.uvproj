# Keil uVision project 最终测试.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 最终测试
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    C:/Users/dell/Desktop/c文件最终/: main.c sx.c tem.c
    ./: Function.c Time_Set.c
